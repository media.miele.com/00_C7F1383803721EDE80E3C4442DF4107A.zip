Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-05-30T12:55:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 30 12:55:24 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\6444fa14-4c3b-44ab-9e51-1a2abb4d8855\e1c22a4f-0a27-4e90-917a-4f23d9141a14\ifc * Database version: 5507 * Database creation date: Tue May 30 12:55:23 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 30 12:55:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 30 12:55:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12440710_CN_DAD4841C_MASW:28D4841M_CN_12440710_DAD4841C_MASW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 28D4841M_CN_12440710_DAD4841C_MASW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28D4841M_CN_12440710_DAD4841C_MASW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, Výchozí Nový materiál, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 936 mm; Height: 730 mm; Depth: 170 mm

# IfcDistributionPort, Port_351014
Description: Flow; FlowDirection: SOURCEANDSINK
